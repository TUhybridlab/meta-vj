SUMMARY = "Mutable variant of collections.namedtuple, which supports assignments"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f8b43802eaad8f2478a4a1c3d1a337e6"

SRC_URI[md5sum] = "40ccc78115aef440ab368bae4c79f6fe"
SRC_URI[sha256sum] = "0910a146b9be3aefe918097f619421202c405ac1e6f1aa8e4fe3dfbd08ea0eb0"

PR = "r0"

inherit pypi setuptools
