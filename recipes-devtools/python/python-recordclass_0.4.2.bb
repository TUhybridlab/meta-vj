SUMMARY = "Mutable variant of collections.namedtuple, which supports assignments"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f8b43802eaad8f2478a4a1c3d1a337e6"

SRC_URI[md5sum] = "cebf86faab9a15dcb943c5f1258a2f4a"
SRC_URI[sha256sum] = "1578273dcaeaf63d697f0c0a9581ecd55d33dcbf8341e6a1c9904a284117dbb7"

PR = "r0"

inherit pypi setuptools
