SUMMARY = "Mutable variant of collections.namedtuple, which supports assignments"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f8b43802eaad8f2478a4a1c3d1a337e6"

SRC_URI[md5sum] = "3e36bba64024b70a49b475fd20b56710"
SRC_URI[sha256sum] = "d5eece506198aab1f39719fc42ab901c5e266a0a8d83d89d40db6cc27d0b9d8b"

PR = "r1"

inherit pypi setuptools
