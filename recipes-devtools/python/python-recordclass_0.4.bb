SUMMARY = "Mutable variant of collections.namedtuple, which supports assignments"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f8b43802eaad8f2478a4a1c3d1a337e6"

SRC_URI[md5sum] = "e49eedffa35380007288158c3eab31e3"
SRC_URI[sha256sum] = "64489016f9fc8df5b575c15285a2ee08cdf2fc44bc92edad47b66acbfc5888ba"

PR = "r0"

inherit pypi setuptools
